# Keil uVision project project.uvprojx, settings and files
target RA8D1 (6190000::V6.19::ARMCLANG)
  device: R7FA8D1BH Renesas
  pack: Renesas.RA_DFP.6.3.0
  cpu: IRAM(0x22000000,0xE0000) IRAM2(0x0,0x10000) IROM(0x02000000,0x001F8000) XRAM(0x20000000,0x10000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: BSP_CFG_RTOS = 0, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, RT_USING_LIBC, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: ..\..\..\rt-thread\components\libc\compilers\common\include;..\..\..\rt-thread\components\libc\compilers\common\extension\fcntl\octal;..\..\..\rt-thread\components\dfs\dfs_v1\filesystems\elmfat;..\..\..\rt-thread\components\libc\posix\io\epoll;..\..\..\rt-thread\components\net\utest;..\..\..\rt-thread\components\drivers\include;..\..\..\rt-thread\components\drivers\smp_call;..\..\..\rt-thread\components\drivers\include;.;..\..\..\rt-thread\components\drivers\include;..\..\..\rt-thread\components\drivers\include;libraries\HAL_Drivers\drivers;board;..\..\..\rt-thread\components\dfs\dfs_v1\include;..\..\..\rt-thread\components\libc\posix\ipc;..\..\..\rt-thread\components\drivers\include;..\..\..\rt-thread\include;..\..\..\rt-thread\components\drivers\include;..\..\..\rt-thread\components\finsh;board\ports\wifi;..\..\..\rt-thread\components\drivers\phy;..\..\..\rt-thread\components\libc\posix\io\poll;..\..\..\rt-thread\libcpu\arm\common;libraries\HAL_Drivers;..\..\..\rt-thread\components\libc\posix\io\eventfd;..\..\..\rt-thread\components\libc\compilers\common\extension;..\..\..\rt-thread\components\dfs\dfs_v1\filesystems\devfs;..\..\..\rt-thread\libcpu\arm\cortex-m85;..\..\..\rt-thread\components\drivers\sdio\sdhci\include;libraries\HAL_Drivers\drivers\config;board\ports\usb_pcdc;..\..\..\rt-thread\components\drivers\include;board\ports;..\..\..\rt-thread\components\drivers\include
  memory RVCT4: ROM 0x2000000 size 0x1f8000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x22000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\script\fsp.scat
  group Compiler
    ../../../rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../rt-thread/components/drivers/block/: blk.c blk_dev.c blk_dfs.c blk_partition.c
    ../../../rt-thread/components/drivers/block/partitions/: dfs.c efi.c
    ../../../rt-thread/components/drivers/core/: device.c
    ../../../rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../rt-thread/components/drivers/pin/: dev_pin.c
    ../../../rt-thread/components/drivers/sdio/: dev_block.c dev_mmc.c dev_mmcsd_core.c dev_sd.c dev_sdio.c
    ../../../rt-thread/components/drivers/serial/: dev_serial_v2.c
  group Drivers
    board/ports/: drv_sdram.c
    board/: ra8_it.c
    libraries/HAL_Drivers/drivers/: drv_gpio.c drv_usart_v2.c
    libraries/HAL_Drivers/: drv_common.c
  group Filesystem
    ../../../rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../rt-thread/components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../rt-thread/components/finsh/: msh_file.c msh.c cmd.c msh_parse.c shell.c
  group Kernel
    ../../../rt-thread/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../rt-thread/src/klibc/: kerrno.c rt_vsscanf.c kstdio.c kstring.c rt_vsnprintf_tiny.c
  group libcpu
    ../../../rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../rt-thread/libcpu/arm/cortex-m85/: context_gcc.S cpuport.c
  group usb_pcdc
    board/ports/usb_pcdc/: usb_pcdc.c r_usb_pcdc_descriptor.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0
