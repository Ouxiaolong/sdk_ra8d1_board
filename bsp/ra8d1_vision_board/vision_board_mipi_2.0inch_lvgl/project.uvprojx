# Keil uVision project project.uvprojx, settings and files
target RA8D1 (6190000::V6.19::ARMCLANG)
  device: R7FA8D1BH Renesas
  pack: Renesas.RA_DFP.5.3.0
  cpu: IRAM(0x22000000,0xE0000) IRAM2(0x0,0x10000) IROM(0x02000000,0x001F8000) XRAM(0x20000000,0x10000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: BSP_CFG_RTOS = 0, __RTTHREAD__, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: packages\cst812t-latest\inc;packages\LVGL-v9.1.0\src\draw\vg_lite;..\..\..\rt-thread\components\drivers\include;packages\LVGL-v9.1.0\src\libs\lz4;board;packages\LVGL-v9.1.0\src\widgets\menu;packages\LVGL-v9.1.0\src\drivers\nuttx;packages\LVGL-v9.1.0\src\themes\mono;packages\LVGL-v9.1.0\src\font;packages\LVGL-v9.1.0\src\widgets\tileview;packages\LVGL-v9.1.0\src\widgets\list;packages\LVGL-v9.1.0\src\libs\gif;packages\LVGL-v9.1.0\src\libs\thorvg;packages\LVGL-v9.1.0\src\libs\tiny_ttf;packages\LVGL-v9.1.0\src\widgets\textarea;packages\LVGL-v9.1.0\src\widgets\animimage;packages\LVGL-v9.1.0\src\widgets\msgbox;board\ports;packages\LVGL-v9.1.0\src\libs\bin_decoder;..\..\..\rt-thread\components\libc\posix\io\poll;packages\LVGL-v9.1.0\src\themes;packages\LVGL-v9.1.0\src\libs\tjpgd;packages\LVGL-v9.1.0\src\themes\simple;packages\LVGL-v9.1.0\src\drivers\display\lcd;packages\LVGL-v9.1.0\src\widgets\roller;packages\LVGL-v9.1.0\src\drivers;..\..\..\rt-thread\include;packages\LVGL-v9.1.0\src\drivers\display\st7789;packages\LVGL-v9.1.0\src\layouts\flex;packages\LVGL-v9.1.0\src\drivers\windows;packages\LVGL-v9.1.0\src\widgets\scale;packages\LVGL-v9.1.0\src\widgets\span;..\..\..\rt-thread\components\finsh;..\..\..\rt-thread\components\libc\compilers\common\extension\fcntl\octal;packages\LVGL-v9.1.0\src\stdlib\builtin;packages\LVGL-v9.1.0\src\widgets\chart;packages\LVGL-v9.1.0\src\drivers\display\fb;..\..\..\rt-thread\components\libc\posix\ipc;packages\LVGL-v9.1.0\src\widgets\led;packages\LVGL-v9.1.0\src\others\ime;packages\LVGL-v9.1.0\src\draw\sw\blend\arm2d;board\lvgl;packages\LVGL-v9.1.0\src\draw\sdl;packages\LVGL-v9.1.0\src\widgets\arc;packages\LVGL-v9.1.0\src\widgets\tabview;..\..\..\rt-thread\components\libc\compilers\common\include;packages\LVGL-v9.1.0\src\drivers\sdl;..\..\..\rt-thread\components\libc\compilers\common\extension;packages\LVGL-v9.1.0\src\libs\rlottie;packages\LVGL-v9.1.0\src\libs\bmp;packages\LVGL-v9.1.0\src\widgets\spinner;packages\LVGL-v9.1.0\src\libs\libjpeg_turbo;board\ports\mipi_lcd;packages\LVGL-v9.1.0\src\draw\sw\blend;packages\LVGL-v9.1.0\src\drivers\display\tft_espi;packages\LVGL-v9.1.0\src\libs\libpng;packages\LVGL-v9.1.0\src\others\snapshot;packages\LVGL-v9.1.0\src\widgets\slider;packages\LVGL-v9.1.0\src\libs\lodepng;packages\LVGL-v9.1.0\src\stdlib;.;..\..\..\rt-thread\components\libc\posix\io\epoll;packages\LVGL-v9.1.0\src\others\sysmon;packages\LVGL-v9.1.0\src;packages\LVGL-v9.1.0\src\widgets\dropdown;board\ports\wifi;packages\LVGL-v9.1.0\src\drivers\x11;..\..\..\rt-thread\components\drivers\touch;..\..\..\rt-thread\components\drivers\include;packages\LVGL-v9.1.0\src\libs\qrcode;packages\LVGL-v9.1.0\src\libs\freetype;packages\LVGL-v9.1.0\src\widgets\keyboard;packages\LVGL-v9.1.0\src\libs\barcode;packages\LVGL-v9.1.0\src\draw\sw\blend\helium;packages\LVGL-v9.1.0\src\widgets\calendar;packages\LVGL-v9.1.0\src\others\vg_lite_tvg;..\..\..\rt-thread\components\drivers\include;..\..\..\rt-thread\components\drivers\include;packages\LVGL-v9.1.0\src\drivers\display\st7735;packages\LVGL-v9.1.0\src\libs\fsdrv;..\..\..\rt-thread\components\drivers\include;packages\LVGL-v9.1.0\src\libs\ffmpeg;packages\LVGL-v9.1.0\src\others\gridnav;board\lvgl\demo;packages\LVGL-v9.1.0\src\display;packages\LVGL-v9.1.0\src\misc;..\..\..\rt-thread\components\libc\posix\io\eventfd;packages\LVGL-v9.1.0\src\widgets\switch;packages\LVGL-v9.1.0\src\draw\renesas\dave2d;packages\LVGL-v9.1.0\src\others\monkey;packages\LVGL-v9.1.0\src\themes\default;packages\LVGL-v9.1.0\src\draw\nxp\pxp;..\..\..\rt-thread\libcpu\arm\common;..\..\..\rt-thread\components\drivers\include;packages\LVGL-v9.1.0\src\draw\sw\arm2d;libraries\HAL_Drivers\drivers;packages\LVGL-v9.1.0\src\layouts;packages\LVGL-v9.1.0\src\draw;packages\LVGL-v9.1.0\src\core;..\..\..\rt-thread\libcpu\arm\cortex-m85;packages\LVGL-v9.1.0\src\osal;packages\LVGL-v9.1.0\src\draw\sw\blend\neon;packages\LVGL-v9.1.0\src\draw\nxp\vglite;packages\LVGL-v9.1.0\src\drivers\display\ili9341;packages\LVGL-v9.1.0\src\widgets\canvas;..\..\..\rt-thread\components\drivers\include;packages\LVGL-v9.1.0\src\widgets\label;..\..\..\rt-thread\components\net\utest;packages\LVGL-v9.1.0\src\widgets\spinbox;packages\LVGL-v9.1.0\src\widgets\checkbox;packages\LVGL-v9.1.0\src\widgets\imagebutton;packages\LVGL-v9.1.0\src\others\file_explorer;packages\LVGL-v9.1.0\src\widgets\objx_templ;packages\LVGL-v9.1.0\src\widgets\table;packages\LVGL-v9.1.0\src\widgets\buttonmatrix;..\..\..\rt-thread\components\drivers\include;packages\LVGL-v9.1.0\src\drivers\libinput;packages\LVGL-v9.1.0\src\widgets\image;libraries\HAL_Drivers\drivers\config;packages\LVGL-v9.1.0\src\draw\sw;packages\LVGL-v9.1.0\env_support\rt-thread;packages\LVGL-v9.1.0\src\tick;packages\LVGL-v9.1.0\src\widgets\bar;packages\LVGL-v9.1.0\src\widgets\win;packages\LVGL-v9.1.0\src\misc\cache;packages\LVGL-v9.1.0\src\drivers\display\drm;packages\LVGL-v9.1.0\src\others\imgfont;packages\LVGL-v9.1.0\src\widgets\button;..\..\..\rt-thread\components\drivers\phy;packages\LVGL-v9.1.0\src\drivers\evdev;packages\LVGL-v9.1.0\src\drivers\display\st7796;packages\LVGL-v9.1.0\src\others\fragment;packages\LVGL-v9.1.0\src\libs\rle;packages\LVGL-v9.1.0\src\widgets\line;libraries\HAL_Drivers;packages\LVGL-v9.1.0\src\indev;packages\LVGL-v9.1.0\src\layouts\grid;packages\LVGL-v9.1.0\src\others\observer;..\..\..\rt-thread\components\drivers\smp_call
  memory RVCT4: ROM 0x2000000 size 0x1f8000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x22000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\script\fsp.scat
  group Compiler
    ../../../rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group cst812t
    packages/cst812t-latest/: cst812t.c
  group DeviceDrivers
    ../../../rt-thread/components/drivers/core/: device.c
    ../../../rt-thread/components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../rt-thread/components/drivers/misc/: rt_drv_pwm.c
    ../../../rt-thread/components/drivers/pin/: dev_pin.c
    ../../../rt-thread/components/drivers/serial/: dev_serial_v2.c
    ../../../rt-thread/components/drivers/touch/: dev_touch.c
  group Drivers
    board/ports/: drv_sdram.c
    board/ports/mipi_lcd/: mipi_config.c
    board/: ra8_it.c
    libraries/HAL_Drivers/drivers/: drv_gpio.c drv_lcd.c drv_pwm.c drv_sci.c drv_usart_v2.c
    libraries/HAL_Drivers/: drv_common.c
  group Finsh
    ../../../rt-thread/components/finsh/: msh_parse.c cmd.c shell.c msh.c
  group Kernel
    ../../../rt-thread/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../rt-thread/src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group libcpu
    ../../../rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../rt-thread/libcpu/arm/cortex-m85/: context_gcc.S cpuport.c
  group LVGL
    packages/LVGL-v9.1.0/src/font/: lv_font_montserrat_18.c lv_font_montserrat_16.c lv_font_montserrat_36.c lv_font_montserrat_22.c lv_font_montserrat_28.c lv_font_montserrat_38.c lv_font_montserrat_28_compressed.c lv_font_montserrat_44.c lv_font_unscii_16.c lv_font_montserrat_34.c lv_font.c lv_font_montserrat_40.c lv_font_montserrat_8.c lv_binfont_loader.c lv_font_montserrat_42.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_10.c lv_font_unscii_8.c lv_font_montserrat_46.c lv_font_montserrat_12.c lv_font_montserrat_24.c lv_font_montserrat_48.c lv_font_montserrat_26.c lv_font_montserrat_14.c lv_font_simsun_16_cjk.c lv_font_fmt_txt.c lv_font_montserrat_20.c lv_font_montserrat_32.c lv_font_montserrat_30.c
    packages/LVGL-v9.1.0/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_layer.c lv_draw_buf_pxp.c lv_draw_pxp_img.c lv_pxp_osa.c lv_pxp_utils.c lv_draw_pxp_fill.c lv_pxp_cfg.c
    packages/LVGL-v9.1.0/src/libs/freetype/: lv_freetype_image.c lv_ftsystem.c lv_freetype.c lv_freetype_outline.c lv_freetype_glyph.c
    packages/LVGL-v9.1.0/src/misc/: lv_color.c lv_math.c lv_fs.c lv_palette.c lv_style_gen.c lv_ll.c lv_area.c lv_event.c lv_anim_timeline.c lv_style.c lv_color_op.c lv_templ.c lv_text.c lv_utils.c lv_array.c lv_bidi.c lv_timer.c lv_async.c lv_text_ap.c lv_log.c lv_anim.c lv_rb.c lv_lru.c lv_profiler_builtin.c
    packages/LVGL-v9.1.0/src/stdlib/: lv_mem.c
    packages/LVGL-v9.1.0/src/draw/nxp/vglite/: lv_vglite_path.c lv_vglite_utils.c lv_draw_vglite_border.c lv_draw_buf_vglite.c lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_line.c lv_draw_vglite_layer.c lv_draw_vglite_triangle.c lv_draw_vglite_img.c lv_draw_vglite_fill.c lv_vglite_buf.c lv_draw_vglite_label.c lv_vglite_matrix.c
    packages/LVGL-v9.1.0/src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_image_cache.c lv_nuttx_touchscreen.c lv_nuttx_libuv.c lv_nuttx_profiler.c lv_nuttx_lcd.c lv_nuttx_entry.c lv_nuttx_fbdev.c
    packages/LVGL-v9.1.0/src/stdlib/builtin/: lv_string_builtin.c lv_tlsf.c lv_mem_core_builtin.c lv_sprintf_builtin.c
    packages/LVGL-v9.1.0/src/others/monkey/: lv_monkey.c
    packages/LVGL-v9.1.0/src/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v9.1.0/src/draw/vg_lite/: lv_vg_lite_math.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_img.c lv_vg_lite_utils.c lv_vg_lite_grad.c lv_vg_lite_pending.c lv_vg_lite_decoder.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_vg_lite_path.c lv_draw_vg_lite_mask_rect.c lv_draw_buf_vg_lite.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_vector.c lv_draw_vg_lite_label.c lv_draw_vg_lite_arc.c lv_draw_vg_lite.c
    packages/LVGL-v9.1.0/src/core/: lv_refr.c lv_obj_draw.c lv_obj_style_gen.c lv_obj_event.c lv_group.c lv_obj.c lv_obj_scroll.c lv_obj_id_builtin.c lv_obj_class.c lv_obj_style.c lv_obj_pos.c lv_obj_property.c lv_obj_tree.c
    packages/LVGL-v9.1.0/src/osal/: lv_rtthread.c lv_windows.c lv_freertos.c lv_pthread.c lv_cmsis_rtos2.c lv_os_none.c
    packages/LVGL-v9.1.0/src/draw/sw/: lv_draw_sw_vector.c lv_draw_sw_letter.c lv_draw_sw_img.c lv_draw_sw_transform.c lv_draw_sw.c lv_draw_sw_triangle.c lv_draw_sw_mask_rect.c lv_draw_sw_box_shadow.c lv_draw_sw_border.c lv_draw_sw_line.c lv_draw_sw_arc.c lv_draw_sw_fill.c lv_draw_sw_gradient.c lv_draw_sw_mask.c
    packages/LVGL-v9.1.0/src/drivers/sdl/: lv_sdl_keyboard.c lv_sdl_mousewheel.c lv_sdl_mouse.c lv_sdl_window.c
    packages/LVGL-v9.1.0/src/libs/barcode/: code128.c lv_barcode.c
    packages/LVGL-v9.1.0/src/libs/tiny_ttf/: lv_tiny_ttf.c
    packages/LVGL-v9.1.0/src/others/vg_lite_tvg/: vg_lite_matrix.c
    packages/LVGL-v9.1.0/src/widgets/label/: lv_label.c
    packages/LVGL-v9.1.0/src/widgets/menu/: lv_menu.c
    packages/LVGL-v9.1.0/src/libs/fsdrv/: lv_fs_memfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_cbfs.c lv_fs_win32.c lv_fs_stdio.c lv_fs_fatfs.c
    packages/LVGL-v9.1.0/src/themes/: lv_theme.c
    packages/LVGL-v9.1.0/src/themes/simple/: lv_theme_simple.c
    packages/LVGL-v9.1.0/src/stdlib/rtthread/: lv_string_rtthread.c lv_mem_core_rtthread.c lv_sprintf_rtthread.c
    packages/LVGL-v9.1.0/src/: lv_init.c
    packages/LVGL-v9.1.0/src/draw/sw/blend/: lv_draw_sw_blend_to_rgb888.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend.c lv_draw_sw_blend_to_rgb565.c
    packages/LVGL-v9.1.0/src/widgets/table/: lv_table.c
    packages/LVGL-v9.1.0/src/widgets/image/: lv_image.c
    packages/LVGL-v9.1.0/src/widgets/led/: lv_led.c
    packages/LVGL-v9.1.0/src/draw/: lv_draw.c lv_draw_triangle.c lv_draw_rect.c lv_draw_mask.c lv_draw_label.c lv_image_decoder.c lv_draw_buf.c lv_draw_arc.c lv_draw_line.c lv_draw_image.c lv_draw_vector.c
    packages/LVGL-v9.1.0/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    packages/LVGL-v9.1.0/src/widgets/canvas/: lv_canvas.c
    packages/LVGL-v9.1.0/src/widgets/roller/: lv_roller.c
    packages/LVGL-v9.1.0/src/display/: lv_display.c
    packages/LVGL-v9.1.0/src/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-v9.1.0/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d_border.c lv_draw_dave2d_arc.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_image.c lv_draw_dave2d_line.c lv_draw_dave2d_utils.c lv_draw_dave2d_triangle.c lv_draw_dave2d_fill.c lv_draw_dave2d_label.c
    packages/LVGL-v9.1.0/src/layouts/flex/: lv_flex.c
    packages/LVGL-v9.1.0/src/stdlib/micropython/: lv_mem_core_micropython.c
    packages/LVGL-v9.1.0/src/others/observer/: lv_observer.c
    packages/LVGL-v9.1.0/src/widgets/scale/: lv_scale.c
    packages/LVGL-v9.1.0/src/drivers/display/fb/: lv_linux_fbdev.c
    packages/LVGL-v9.1.0/src/widgets/imagebutton/: lv_imagebutton.c
    packages/LVGL-v9.1.0/src/widgets/tileview/: lv_tileview.c
    packages/LVGL-v9.1.0/src/widgets/switch/: lv_switch.c
    packages/LVGL-v9.1.0/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    packages/LVGL-v9.1.0/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    packages/LVGL-v9.1.0/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    packages/LVGL-v9.1.0/src/drivers/libinput/: lv_libinput.c lv_xkb.c
    packages/LVGL-v9.1.0/src/widgets/slider/: lv_slider.c
    packages/LVGL-v9.1.0/src/widgets/tabview/: lv_tabview.c
    packages/LVGL-v9.1.0/src/draw/sdl/: lv_draw_sdl.c
    packages/LVGL-v9.1.0/src/layouts/grid/: lv_grid.c
    packages/LVGL-v9.1.0/src/misc/cache/: lv_cache_entry.c lv_image_cache.c lv_cache.c _lv_cache_lru_rb.c
    packages/LVGL-v9.1.0/src/widgets/chart/: lv_chart.c
    packages/LVGL-v9.1.0/src/widgets/checkbox/: lv_checkbox.c
    packages/LVGL-v9.1.0/src/widgets/win/: lv_win.c
    packages/LVGL-v9.1.0/src/libs/libpng/: lv_libpng.c
    packages/LVGL-v9.1.0/src/drivers/windows/: lv_windows_input.c lv_windows_display.c lv_windows_context.c
    packages/LVGL-v9.1.0/src/others/ime/: lv_ime_pinyin.c
    packages/LVGL-v9.1.0/src/widgets/dropdown/: lv_dropdown.c
    packages/LVGL-v9.1.0/src/libs/bmp/: lv_bmp.c
    packages/LVGL-v9.1.0/src/libs/lodepng/: lodepng.c lv_lodepng.c
    packages/LVGL-v9.1.0/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    packages/LVGL-v9.1.0/src/widgets/spinner/: lv_spinner.c
    packages/LVGL-v9.1.0/src/drivers/display/ili9341/: lv_ili9341.c
    packages/LVGL-v9.1.0/src/drivers/x11/: lv_x11_display.c lv_x11_input.c
    packages/LVGL-v9.1.0/src/widgets/bar/: lv_bar.c
    packages/LVGL-v9.1.0/src/others/sysmon/: lv_sysmon.c
    packages/LVGL-v9.1.0/src/libs/rle/: lv_rle.c
    packages/LVGL-v9.1.0/src/widgets/calendar/: lv_calendar_header_dropdown.c lv_calendar_header_arrow.c lv_calendar.c
    packages/LVGL-v9.1.0/src/drivers/display/st7735/: lv_st7735.c
    packages/LVGL-v9.1.0/src/others/imgfont/: lv_imgfont.c
    packages/LVGL-v9.1.0/src/widgets/span/: lv_span.c
    packages/LVGL-v9.1.0/src/widgets/line/: lv_line.c
    packages/LVGL-v9.1.0/src/layouts/: lv_layout.c
    packages/LVGL-v9.1.0/src/libs/gif/: lv_gif.c gifdec.c
    packages/LVGL-v9.1.0/src/tick/: lv_tick.c
    packages/LVGL-v9.1.0/src/libs/bin_decoder/: lv_bin_decoder.c
    packages/LVGL-v9.1.0/src/themes/mono/: lv_theme_mono.c
    packages/LVGL-v9.1.0/src/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v9.1.0/src/widgets/arc/: lv_arc.c
    packages/LVGL-v9.1.0/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
    packages/LVGL-v9.1.0/src/widgets/button/: lv_button.c
    packages/LVGL-v9.1.0/src/others/file_explorer/: lv_file_explorer.c
    packages/LVGL-v9.1.0/src/widgets/objx_templ/: lv_objx_templ.c
    packages/LVGL-v9.1.0/src/others/snapshot/: lv_snapshot.c
    packages/LVGL-v9.1.0/src/indev/: lv_indev_scroll.c lv_indev.c
    packages/LVGL-v9.1.0/src/drivers/display/drm/: lv_linux_drm.c
    packages/LVGL-v9.1.0/src/widgets/list/: lv_list.c
    packages/LVGL-v9.1.0/src/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-v9.1.0/src/drivers/evdev/: lv_evdev.c
    packages/LVGL-v9.1.0/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
    packages/LVGL-v9.1.0/src/drivers/display/st7796/: lv_st7796.c
    packages/LVGL-v9.1.0/src/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-v9.1.0/src/libs/lz4/: lz4.c
    packages/LVGL-v9.1.0/src/widgets/textarea/: lv_textarea.c
    packages/LVGL-v9.1.0/src/others/gridnav/: lv_gridnav.c
    packages/LVGL-v9.1.0/src/themes/default/: lv_theme_default.c
    packages/LVGL-v9.1.0/src/drivers/display/st7789/: lv_st7789.c
    packages/LVGL-v9.1.0/src/widgets/animimage/: lv_animimage.c
  group LVGL-demo
    board/lvgl/demo/benchmark/assets/: img_benchmark_cogwheel_alpha256.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c img_transform_avatar_15.c lv_font_benchmark_montserrat_12_compr_az.c.c lv_font_benchmark_montserrat_16_compr_az.c.c lv_font_benchmark_montserrat_28_compr_az.c.c
    board/lvgl/demo/benchmark/: lv_demo_benchmark.c
    board/lvgl/demo/: lv_demo.c
    board/lvgl/demo/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_demo_widgets_needle.c img_lvgl_logo.c
    board/lvgl/demo/widgets/: lv_demo_widgets.c
  group LVGL-port
    board/lvgl/: lv_port_disp.c lv_port_indev.c mouse_cursor_icon.c
    packages/LVGL-v9.1.0/env_support/rt-thread/: lv_rt_thread_port.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0
