# Keil uVision project project.uvprojx, settings and files
target RA8D1 (6190000::V6.19::ARMCLANG)
  device: R7FA8D1BH Renesas
  pack: Renesas.RA_DFP.5.3.0
  cpu: IRAM(0x22000000,0xE0000) IRAM2(0x0,0x10000) IROM(0x02000000,0x001F8000) XRAM(0x20000000,0x10000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARMLIBC, __RTTHREAD__, __STDC_LIMIT_MACROS
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: ..\..\..\rt-thread\components\net\lwip\lwip-2.0.3\src\include\ipv4;..\..\..\rt-thread\components\drivers\include;board\ports;..\..\..\rt-thread\components\net\sal\include\socket;..\..\..\rt-thread\components\net\lwip\lwip-2.0.3\src\include\netif;libraries\HAL_Drivers;..\..\..\rt-thread\components\net\sal\impl;..\..\..\rt-thread\components\net\lwip\lwip-2.0.3\src\include;..\..\..\rt-thread\components\drivers\include;..\..\..\rt-thread\include;.;..\..\..\rt-thread\components\drivers\include;board;..\..\..\rt-thread\components\drivers\phy;libraries\HAL_Drivers\drivers;..\..\..\rt-thread\components\net\sal\include\socket\sys_socket;..\..\..\rt-thread\components\libc\posix\io\poll;..\..\..\rt-thread\components\net\lwip\port;..\..\..\rt-thread\components\libc\posix\io\epoll;..\..\..\rt-thread\components\finsh;..\..\..\rt-thread\libcpu\arm\common;..\..\..\rt-thread\components\drivers\smp_call;..\..\..\rt-thread\components\net\sal\include;..\..\..\rt-thread\components\libc\posix\io\eventfd;..\..\..\rt-thread\components\libc\compilers\common\include;..\..\..\rt-thread\components\libc\compilers\common\extension\fcntl\octal;libraries\HAL_Drivers\drivers\config;..\..\..\rt-thread\components\net\netdev\include;..\..\..\rt-thread\components\libc\compilers\common\extension;..\..\..\rt-thread\components\libc\posix\ipc;..\..\..\rt-thread\components\drivers\include;..\..\..\rt-thread\libcpu\arm\cortex-m85;..\..\..\rt-thread\components\net\utest;..\..\..\rt-thread\components\drivers\include
  memory RVCT4: ROM 0x2000000 size 0x1f8000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x22000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\script\fsp.scat
  group Compiler
    ../../../rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../rt-thread/components/drivers/core/: device.c
    ../../../rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../rt-thread/components/drivers/pin/: dev_pin.c
    ../../../rt-thread/components/drivers/serial/: dev_serial_v2.c
  group Drivers
    board/ports/: drv_sdram.c
    board/: ra8_it.c
    libraries/HAL_Drivers/drivers/: drv_eth.c drv_gpio.c drv_usart_v2.c
    libraries/HAL_Drivers/: drv_common.c
  group Finsh
    ../../../rt-thread/components/finsh/: cmd.c msh.c msh_parse.c shell.c
  group Kernel
    ../../../rt-thread/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../rt-thread/src/klibc/: kstdio.c kerrno.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group libcpu
    ../../../rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../rt-thread/libcpu/arm/cortex-m85/: context_gcc.S cpuport.c
  group lwIP
    ../../../rt-thread/components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../rt-thread/components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    ../../../rt-thread/components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../rt-thread/components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../rt-thread/components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    ../../../rt-thread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group SAL
    ../../../rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../rt-thread/components/net/sal/impl/: af_inet_lwip.c
    ../../../rt-thread/components/net/sal/socket/: net_netdb.c
    ../../../rt-thread/components/net/sal/src/: sal_socket.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0
