# Keil uVision project project.uvprojx, settings and files
target RA8D1 (6190000::V6.19::ARMCLANG)
  device: R7FA8D1BH Renesas
  pack: Renesas.RA_DFP.5.3.0
  cpu: IRAM(0x22000000,0xE0000) IRAM2(0x0,0x10000) IROM(0x02000000,0x001F8000) XRAM(0x20000000,0x10000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: RT_USING_LIBC, __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, BSP_CFG_RTOS = 0, RT_USING_ARMLIBC
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: ..\..\..\rt-thread\components\libc\posix\io\eventfd;..\..\..\rt-thread\include;libraries\HAL_Drivers\drivers;..\..\..\rt-thread\components\drivers\phy;libraries\HAL_Drivers;..\..\..\rt-thread\components\dfs\dfs_v1\filesystems\devfs;..\..\..\rt-thread\components\net\lwip\lwip-2.0.3\src\include\netif;..\..\..\rt-thread\components\drivers\include;..\..\..\rt-thread\components\drivers\wlan;..\..\..\rt-thread\components\net\sal\include;..\..\..\rt-thread\libcpu\arm\common;board\ports;..\..\..\rt-thread\components\finsh;..\..\..\rt-thread\components\net\lwip\lwip-2.0.3\src\include;libraries\HAL_Drivers\drivers\config;..\..\..\rt-thread\components\drivers\include;..\..\..\rt-thread\components\libc\posix\io\epoll;..\..\..\rt-thread\components\net\utest;board;..\..\..\rt-thread\components\net\sal\include\dfs_net;packages\rw007-v2.1.0;..\..\..\rt-thread\components\dfs\dfs_v1\include;..\..\..\rt-thread\components\net\sal\impl;..\..\..\rt-thread\components\drivers\include;..\..\..\rt-thread\components\net\lwip\lwip-2.0.3\src\include\ipv4;..\..\..\rt-thread\components\drivers\spi;..\..\..\rt-thread\components\libc\posix\ipc;..\..\..\rt-thread\components\drivers\include;..\..\..\rt-thread\components\net\netdev\include;..\..\..\rt-thread\components\net\sal\include\socket\sys_socket;..\..\..\rt-thread\components\libc\compilers\common\extension;..\..\..\rt-thread\libcpu\arm\cortex-m85;packages\rw007-v2.1.0\inc;..\..\..\rt-thread\components\drivers\include;..\..\..\rt-thread\components\drivers\smp_call;..\..\..\rt-thread\components\libc\compilers\common\include;.;..\..\..\rt-thread\components\net\sal\include\socket;..\..\..\rt-thread\components\drivers\include;board\ports\wifi;..\..\..\rt-thread\components\libc\compilers\common\extension\fcntl\octal;..\..\..\rt-thread\components\libc\posix\io\poll;..\..\..\rt-thread\components\net\lwip\port
  memory RVCT4: ROM 0x2000000 size 0x1f8000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x22000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\script\fsp.scat
  group Compiler
    ../../../rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../rt-thread/components/drivers/core/: device.c
    ../../../rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../rt-thread/components/drivers/pin/: dev_pin.c
    ../../../rt-thread/components/drivers/serial/: dev_serial_v2.c
    ../../../rt-thread/components/drivers/spi/: dev_spi.c dev_spi_core.c
    ../../../rt-thread/components/drivers/wlan/: dev_wlan.c dev_wlan_cfg.c dev_wlan_cmd.c dev_wlan_lwip.c dev_wlan_mgnt.c dev_wlan_prot.c dev_wlan_workqueue.c
  group Drivers
    board/ports/: drv_sdram.c
    board/ports/wifi/: drv_rw007.c
    board/: ra8_it.c
    libraries/HAL_Drivers/drivers/: drv_gpio.c drv_spi.c drv_usart_v2.c
    libraries/HAL_Drivers/: drv_common.c
  group Filesystem
    ../../../rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../rt-thread/components/finsh/: msh_file.c msh_parse.c msh.c cmd.c shell.c
  group Kernel
    ../../../rt-thread/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../rt-thread/src/klibc/: kerrno.c rt_vsnprintf_tiny.c kstring.c kstdio.c rt_vsscanf.c
  group libcpu
    ../../../rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../rt-thread/libcpu/arm/cortex-m85/: context_gcc.S cpuport.c
  group lwIP
    ../../../rt-thread/components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../rt-thread/components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    ../../../rt-thread/components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../rt-thread/components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../rt-thread/components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    ../../../rt-thread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group NetUtils
    packages/netutils-latest/iperf/: iperf.c
    packages/netutils-latest/netio/: netio.c
  group POSIX
    ../../../rt-thread/components/libc/posix/io/poll/: poll.c select.c
  group rw007
    packages/rw007-v2.1.0/src/: spi_wifi_rw007.c
  group SAL
    ../../../rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../rt-thread/components/net/sal/dfs_net/: dfs_net.c
    ../../../rt-thread/components/net/sal/impl/: af_inet_lwip.c
    ../../../rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../../rt-thread/components/net/sal/src/: sal_socket.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0
