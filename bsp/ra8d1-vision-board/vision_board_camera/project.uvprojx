# Keil uVision project project.uvprojx, settings and files
target RA8D1 (6190000::V6.19::ARMCLANG)
  device: R7FA8D1BH Renesas
  pack: Renesas.RA_DFP.5.3.0
  cpu: IRAM(0x22000000,0xE0000) IRAM2(0x0,0x10000) IROM(0x02000000,0x001F8000) XRAM(0x20000000,0x10000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: RT_USING_ARMLIBC, BSP_CFG_RTOS = 0, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, RT_USING_LIBC, __RTTHREAD__
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: libraries\HAL_Drivers\drivers;..\..\..\rt-thread\components\libc\posix\io\poll;board\ports\camera;..\..\..\rt-thread\components\libc\posix\io\eventfd;..\..\..\rt-thread\components\net\utest;..\..\..\rt-thread\components\libc\posix\ipc;..\..\..\rt-thread\components\drivers\include;..\..\..\rt-thread\components\drivers\include;..\..\..\rt-thread\include;board;..\..\..\rt-thread\components\drivers\include;..\..\..\rt-thread\components\drivers\include;..\..\..\rt-thread\components\libc\compilers\common\extension;libraries\HAL_Drivers;..\..\..\rt-thread\components\drivers\include;libraries\HAL_Drivers\drivers\config;.;..\..\..\rt-thread\components\finsh;..\..\..\rt-thread\components\drivers\smp_call;board\ports\wifi;..\..\..\rt-thread\components\drivers\include;..\..\..\rt-thread\components\libc\compilers\common\extension\fcntl\octal;..\..\..\rt-thread\components\drivers\include;..\..\..\rt-thread\libcpu\arm\common;board\ports;..\..\..\rt-thread\components\libc\compilers\common\include;..\..\..\rt-thread\components\libc\posix\io\epoll;..\..\..\rt-thread\components\drivers\phy;board\ports\mipi_lcd;..\..\..\rt-thread\libcpu\arm\cortex-m85;board\ports\camera\sensors
  memory RVCT4: ROM 0x2000000 size 0x1f8000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x22000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\script\fsp.scat
  group Camera
    board/ports/camera/sensors/: hm0360.c mt9v0xx.c mt9m114.c ov7670.c paj6100.c hm01b0.c gc0328.c ov5640.c ov7690.c ov7725.c ov9650.c ov2640.c gc2145.c frogeye2020.c
    board/ports/camera/: fmath.c sensor.c sensor_utils.c cambus.c
  group Compiler
    ../../../rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../rt-thread/components/drivers/core/: device.c
    ../../../rt-thread/components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../rt-thread/components/drivers/misc/: rt_drv_pwm.c
    ../../../rt-thread/components/drivers/pin/: dev_pin.c
    ../../../rt-thread/components/drivers/serial/: dev_serial_v2.c
  group Drivers
    board/ports/: drv_sdram.c
    board/ports/mipi_lcd/: mipi_config.c
    board/: ra8_it.c
    libraries/HAL_Drivers/drivers/: drv_gpio.c drv_lcd.c drv_pwm.c drv_soft_i2c.c drv_usart_v2.c
    libraries/HAL_Drivers/: drv_common.c
  group Finsh
    ../../../rt-thread/components/finsh/: cmd.c shell.c msh_parse.c msh.c
  group Kernel
    ../../../rt-thread/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../rt-thread/src/klibc/: kstring.c kstdio.c rt_vsscanf.c rt_vsnprintf_tiny.c kerrno.c
  group libcpu
    ../../../rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../rt-thread/libcpu/arm/cortex-m85/: context_gcc.S cpuport.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0
